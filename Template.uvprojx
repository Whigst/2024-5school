# Keil uVision project Template.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: .\Core;.\Library\inc;.\User;.\System\delay;.\System\sys;.\System\usart;.\Hardware;.\DRIVE;.\Hardware\Hardware_H;.\DRIVE\DRIVE_h
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Core
    ./Core/: startup_stm32f40_41xxx.s
  group User
    ./User/: main.c stm32f4xx_it.c system_stm32f4xx.c
  group Library
    ./Library/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_usart.c stm32f4xx_syscfg.c stm32f4xx_iwdg.c stm32f4xx_wwdg.c stm32f4xx_exti.c stm32f4xx_tim.c stm32f4xx_fsmc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c
  group System
    ./System/delay/: delay.c
    ./System/sys/: sys.c
    ./System/usart/: usart.c
  group HardWare
    ./Hardware/: display.c encode_init.c filter.c init_total.c io_init.c key.c lcd.c led.c ms53l1m.c ov5640.c pid.c pwm.c timer.c wit_c_sdk.c
  group DRIVE
    ./DRIVE/: dcmi.c ov5640_bw.c sccb.c
